inherit externalsrc

#follow GNSS1 UM2909 from st.com for below macro
EXTERNALSRC="/add/sources/path/here"

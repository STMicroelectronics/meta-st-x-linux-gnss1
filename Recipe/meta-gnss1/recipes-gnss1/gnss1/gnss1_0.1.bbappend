inherit externalsrc
EXTERNALSRC="Location to <Distribution-Package/build-openstlinuxweston-stm32mp1/X-LINUX-GNSS1_V1.0.0/Application/Source/gnss_x_linux/Sources> Download it from : https://github.com/STMicroelectronics/x-linux-gnss1/tree/main/Application/Source/gnss_x_linux/Sources"
